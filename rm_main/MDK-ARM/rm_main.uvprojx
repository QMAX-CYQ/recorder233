# Keil uVision project rm_main.uvprojx, settings and files
target rm_main (6160000::V6.16::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: rm_main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__TARGET_FPU_VFP
  c include: ../Drivers/CMSIS/Include;../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../User/Communication;../User/Drivers;../User/Protocol;../User/Math/DSP/Include;../User/Math;../User/Model;../User/Support;../User/Middle;../User/Task;../User/UI;../User/Fsm;../User/Recorder;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src
  asm include: ..\Core\Inc;../Core/Inc;../Drivers/CMSIS/Include;../Drivers/BSP/Components/vl53l4cd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
    ./rm_main/: rm_main.sct rm_main.map
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c iwdg.c rng.c rtc.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group User/Task
    ../User/Task/: board_comm_task.c debug_task.c comm_task.c mode_switch_task.c status_task.c gimbal_task.c chassis_task.c shoot_task.c ui_task.c container_task.c control_def.h
  group User/Comm
    ../User/Communication/: can_comm.c board_comm.c usart_comm.c container.c container_bus.c
  group User/Drivers
    ../User/Drivers/: drv_dji_motor.c drv_dm_motor.c drv_lk_motor.c drv_ws2812b.c
  group User/Protocol
    ../User/Support/: data_list.h
    ../User/Protocol/: prot_dr16.c prot_imu.c prot_hipnuc.c prot_judge.c prot_vision.c prot_power.c prot_tfmini.c prot_ms53l0m.c
  group User/Math
    ../User/Math/DSP/: arm_cortexM7lfdp_math.lib
    ../User/Math/: crc.c filter.c kalman_filter.c math_lib.c math_matrix.c pid.c KNN.c SMC.c dwt.c velocity_control.c
  group User/UI
    ../User/UI/: ui_interface.c ui_g.c
  group User/Model
    ../User/Model/: wlr.c leg_vmc.c wheel_leg_model.c
  group User/Support
    ../User/Support/: data_buffer.c data_fifo.c data_log.c func_generator.c us_time.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group User/Fsm
    ../User/Fsm/: fsm_core.c robot_logic.c
  group User/Recorder
    ../User/Recorder/: calendar.c log.c lwrb.c lwrb_ex.c recorder.c recorder_inter.h
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
software components: CMSIS:CORE 5.4.0
