# Keil uVision project spi_validation.uvprojx, settings and files
target rm_main (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: rm_main +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File "D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Support\sync_dma_memory.ps1" -IocPath "D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\spi_config.ioc"
  c flags: Optim=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__TARGET_FPU_VFP,debug_task=log_task,DebugTaskHandle=LogTaskHandle
  c include: D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Log;D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Support;D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Task;D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Usb_device;D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\USB\Usb_device;D:\RM\recorder233\recorder_f405\diagnostics\user_add_spi_split\package\SPI;D:\RM\recorder233\recorder_f405\diagnostics\user_add_spi_split\package\USB;D:\RM\rm_main_gimbal\Drivers\CMSIS\Include;D:\RM\rm_main_gimbal\Core\Inc;D:\RM\rm_main_gimbal\Drivers\STM32H7xx_HAL_Driver\Inc;D:\RM\rm_main_gimbal\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;D:\RM\rm_main_gimbal\Drivers\CMSIS\Device\ST\STM32H7xx\Include;D:\RM\rm_main_gimbal\Middlewares\Third_Party\FreeRTOS\Source\include;D:\RM\rm_main_gimbal\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;D:\RM\rm_main_gimbal\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;D:\RM\rm_main_gimbal\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;D:\RM\rm_main_gimbal\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;D:\RM\rm_main_gimbal\USB_DEVICE\App;D:\RM\rm_main_gimbal\USB_DEVICE\Target;D:\RM\rm_main_gimbal\User\Communication;D:\RM\rm_main_gimbal\User\Drivers;D:\RM\rm_main_gimbal\User\Protocol;D:\RM\rm_main_gimbal\User\Math\DSP\Include;D:\RM\rm_main_gimbal\User\Math;D:\RM\rm_main_gimbal\User\Support;D:\RM\rm_main_gimbal\User\Middle;D:\RM\rm_main_gimbal\User\Task
  asm include: D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Log;D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Support;D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Task;D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Usb_device;D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\USB\Usb_device;D:\RM\recorder233\recorder_f405\diagnostics\user_add_spi_split\package\SPI;D:\RM\recorder233\recorder_f405\diagnostics\user_add_spi_split\package\USB;D:\RM\rm_main_gimbal\Core\Inc;D:\RM\rm_main_gimbal\Core\Inc;D:\RM\rm_main_gimbal\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: D:\RM\recorder233\recorder_f405\diagnostics\dma_memory_config\package\SPI\Log\fault_noinit.sct
  group Application/MDK-ARM
    D:/RM/rm_main_gimbal/MDK-ARM/: startup_stm32h723xx.s
  group Application/User/Core
    D:/RM/recorder233/recorder_f405/diagnostics/dma_memory_config/: main.c
    D:/RM/rm_main_gimbal/Core/Src/: gpio.c freertos.c dma.c fdcan.c iwdg.c rng.c spi.c tim.c usart.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
    D:/RM/recorder233/recorder_f405/diagnostics/nmi_log_refresh/: package_stm32h7xx_it.c
  group Application/User/USB_DEVICE/App
    D:/RM/rm_main_gimbal/USB_DEVICE/App/: usb_device.c usbd_desc.c
    D:/RM/recorder233/recorder_f405/diagnostics/dma_memory_config/package/USB/Usb_device/: usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    D:/RM/recorder233/recorder_f405/diagnostics/dma_memory_config/: usbd_conf.c
  group User/Task
    D:/RM/recorder233/recorder_f405/diagnostics/dma_memory_config/package/SPI/Task/: log_task.c
    D:/RM/rm_main_gimbal/User/Task/: comm_task.c board_comm_task.c mode_switch_task.c gimbal_task.c shoot_task.c control_def.h
    D:/RM/recorder233/recorder_f405/diagnostics/user_add_status_refresh/: status_task.c
  group User/Comm
    D:/RM/rm_main_gimbal/User/Communication/: can_comm.c usart_comm.c board_comm.c container.c container_bus.c
  group User/Drivers
    D:/RM/rm_main_gimbal/User/Drivers/: drv_dji_motor.c drv_dm_motor.c bsp_LK_Motor_MG4005.c drv_lk_motor.c
  group User/Protocol
    D:/RM/rm_main_gimbal/User/Protocol/: prot_dr16.c prot_imu.c prot_judge.c prot_power.c prot_vision.c prot_vtm.c
  group User/Math
    D:/RM/rm_main_gimbal/User/Math/DSP/: arm_cortexM7lfdp_math.lib
    D:/RM/rm_main_gimbal/User/Math/: crc.c filter.c kalman_filter.c math_lib.c math_matrix.c pid.c KNN.c SMC.c gimbal_decoupling.c
  group User/Support
    D:/RM/rm_main_gimbal/User/Support/: data_list.h data_buffer.c data_fifo.c data_log.c func_generator.c us_time.c
    D:/RM/recorder233/recorder_f405/diagnostics/dma_memory_config/package/SPI/Log/: log.c fault_log.c fault_log_port.c nmi_log.c
  group Drivers/CMSIS
    D:/RM/rm_main_gimbal/Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    D:/RM/rm_main_gimbal/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    D:/RM/rm_main_gimbal/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    D:/RM/rm_main_gimbal/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    D:/RM/rm_main_gimbal/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    D:/RM/rm_main_gimbal/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    D:/RM/rm_main_gimbal/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    D:/RM/rm_main_gimbal/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group User_add DCache
    D:/RM/recorder233/recorder_f405/diagnostics/dma_memory_config/package/SPI/Support/: dcache_handle.c
    D:/RM/recorder233/recorder_f405/diagnostics/dma_memory_config/package/SPI/Log/: status_log.c
  group SPI Log DMA
    D:/RM/recorder233/recorder_f405/diagnostics/dma_memory_config/package/SPI/Log/: spi_log.c
software components: CMSIS:CORE 6.1.1
